CONNECTIVITY_PACKAGES_append = " kernel-module-r8723bs rtl8723bs"
