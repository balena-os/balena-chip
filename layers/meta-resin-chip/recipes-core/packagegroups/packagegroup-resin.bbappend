RDEPENDS_${PN} += " resin-udevmount"

RDEPENDS_${PN}_remove = "resin-filesystem-expand"
